# Keil uVision project Template.uvprojx, settings and files
target Template (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;.\led;.\key;.\beep;.\keyint;.\uart;.\time6;.\tim3;.\adc;.\lcd1602;.\oled;.\motor;.\ds18b20;.\dht11;.\sg90
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c system_config.h
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/sys/: sys.c sys.h
  group README
    ../: README.TXT
  group led
    ./led/: led.c led.h
  group key
    ./key/: key.c key.h
  group keyint
    ./keyint/: keyint.c keyint.h
  group beep
    ./beep/: beep.c beep.h
  group uart
    ./uart/: uart.c uart.h
  group time6
    ./time6/: tim6.c tim6.h
  group dlc
    ./dlc/: beifen.c
  group tim3
    ./tim3/: tim3.c tim3.h
  group adc
    ./adc/: adc.c adc.h
  group lcd1602
    ./lcd1602/: lcd1602.c lcd1602.h
  group oled
    ./oled/: oled_iic.c oled_iic.h oledfont.h
  group motor
    ./motor/: motor.c motor.h
  group ds18b20
    ./ds18b20/: ds18b20.c ds18b20.h
  group dht11
    ./dht11/: dht11_driver.c dht11_driver.h
  group sg90
    ./sg90/: sg90.c sg90.h
